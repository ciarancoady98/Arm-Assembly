# Keil uVision project FirstProgram.uvproj, settings and files
target External SDRAM (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FirstProgram
  c flags: Optim=1
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ../libcs1021/: libcs1021.lib
  group Application Code
    ./: FirstProgram.s
target Simulator (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: FirstProgram
  c flags: Optim=1
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
